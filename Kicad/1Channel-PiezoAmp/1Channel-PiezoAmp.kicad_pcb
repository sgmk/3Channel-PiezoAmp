# Repository sgmk/3Channel-PiezoAmp

File README.md:

# 3Channel-PiezoAmp
Extended SMD version of Ralf's Piezo Pre-Amp

See more info on the SGMK wiki

https://wiki.sgmk-ssam.ch/wiki/Ralf%27s_Piezo-Amp

## Version 02

## Hacks to make the LEDs blink

## Version 01

## Case studies

## KiCad design Kicad/1Channel-PiezoAmp/1Channel-PiezoAmp.kicad_pcb

Board: 2 copper layers, 25 parts (5 on the bottom side), 17 nets, no tracks yet.

Parts:
BT1: Battery; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
C1: 10uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C2: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C3: 1nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C4, C5: 1uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C6: 100uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C7: 100pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C9: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1, D2: 1N4148; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: InputJack1; Jack_3.5mm_dusjagr_Horizontal
J2: OutputJack1; Jack_3.5mm_dusjagr_Horizontal
LED1: LED1; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Q1: BC547; SOT-23_Handsoldering
R1, R2, R7, R8: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R3: 4.7k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R4, R6: 1k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R5: 2.2M; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
RV1: Pot1; RD901F-ALPHA-3D
U1: TL072; SSOP-8_3.9x5.05mm_P1.27mm

Connections:
4.5V: C1.1, R1.2, R2.1, U1.3, U1.5
+9V: BT1.1, C6.1, D1.1, LED1.2, R1.1, U1.8
GND: C1.2, D2.2, J1.S, J2.S, Q1.3, R2.2, RV1.3, U1.4
GNDswitch: BT1.2, C6.2, J1.R
unnamed: C2.1, C3.2, R5.2, U1.2
unnamed: C2.2, D1.2, D2.1, J1.T
unnamed: C3.1, R5.1, R6.2, U1.1
unnamed: C4.1, R6.1
unnamed: C4.2, RV1.1
unnamed: C5.2, R7.2
unnamed: C7.1, C9.1, R8.1, U1.7
unnamed: C7.2, R7.1, R8.2, U1.6
unnamed: C9.2, J2.T
unnamed: LED1.1, R4.2
unnamed: Q1.1, R4.1
unnamed: Q1.2, R3.1
Sig1: C5.1, R3.2, RV1.2

## KiCad design Kicad/3Channel-PiezoAmp/3Channel-PiezoAmp.kicad_pcb

Parts:
BT1: Battery; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
C1: 10uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C2, C3, C4: 100nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C5, C6, C7: 1nF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C8, C9, C10, C11, C12, C13: 1uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C14: 100uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C15: 100pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C16: 220uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C17: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1, D2, D3, D4, D5, D6: 1N4148; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: InputJack1; Jack_3.5mm_dusjagr_Horizontal
J2: InputJack2; Jack_3.5mm_dusjagr_Horizontal
J3: InputJack3; Jack_3.5mm_dusjagr_Horizontal
J4: OutputJack1; Jack_3.5mm_dusjagr_Horizontal
J5: DC_Jack_SW_inv; BarrelJack_Horizontal
LED1: LED1; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
LED2: LED2; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
LED3: LED3; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Q1, Q2, Q3: BC547; SOT-23_Handsoldering
R1, R2, R9, R10, R11, R12: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R3, R4, R5: 2.2M; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R6, R7, R8, R14, R15, R16: 1k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R13: 10; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R17, R18, R19: 4.7k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
RV1: Pot1; RD901F-ALPHA-3D
RV2: Pot2; RD901F-ALPHA-3D
RV3: Pot3; RD901F-ALPHA-3D
U1: TL074; SO-14_5.3x10.2mm_P1.27mm

Connections:
4.5V: C1.1, R1.2, R2.1, U1.3 (+), U1.5 (+), U1.10 (+), U1.12 (+)
+9V: BT1.1 (+), C14.1, D1.1 (K), D3.1 (K), D5.1 (K), LED1.2 (A), LED2.2 (A), LED3.2 (A), R1.1, U1.4 (V+)
GND: C1.2, C16.2, D2.2 (A), D4.2 (A), D6.2 (A), J1.S, J2.S, J3.S, J4.S, J5.1, Q1.3, Q2.3, Q3.3, R2.2, RV1.3, RV2.3, RV3.3, U1.11 (V-)
GNDswitch: BT1.2 (-), C14.2, J1.R, J2.R, J3.R
unnamed: C2.1, C5.2, R3.2, U1.13 (-)
unnamed: C2.2, D1.2 (A), D2.1 (K), J1.T
unnamed: C3.1, C6.2, R4.2, U1.9 (-)
unnamed: C3.2, D3.2 (A), D4.1 (K), J2.T
unnamed: C4.1, C7.2, R5.2, U1.2 (-)
unnamed: C4.2, D5.2 (A), D6.1 (K), J3.T
unnamed: C5.1, R3.1, R6.2, U1.14
unnamed: C6.1, R4.1, R7.2, U1.8
unnamed: C7.1, R5.1, R8.2, U1.1
unnamed: C8.1, R6.1
unnamed: C8.2, RV1.1
unnamed: C9.1, R7.1
unnamed: C9.2, RV2.1
unnamed: C10.1, R8.1
unnamed: C10.2, RV3.1
unnamed: C11.2, R9.2
unnamed: C12.2, R10.2
unnamed: C13.2, R11.2
unnamed: C15.1, C17.1, R12.1, U1.7
unnamed: C15.2, R9.1, R10.1, R11.1, R12.2, U1.6 (-)
unnamed: C16.1, R13.2
unnamed: C17.2, J4.T
unnamed: J5.2, R13.1
unnamed: LED1.1 (K), R14.2
unnamed: LED2.1 (K), R15.2
unnamed: LED3.1 (K), R16.2
unnamed: Q1.1, R14.1
unnamed: Q1.2, R17.1
unnamed: Q2.1, R15.1
unnamed: Q2.2, R18.1
unnamed: Q3.1, R16.1
unnamed: Q3.2, R19.1
Sig1: C11.1, R17.2, RV1.2
Sig2: C12.1, R18.2, RV2.2
Sig3: C13.1, R19.2, RV3.2

Notes on the sheet:
Experimental

Board: 2 copper layers, 91.5 x 53.0 mm, 55 parts (37 on the bottom side), 37 nets.

## Commit log

2020-10-05 adding folders
2020-10-15 finished schematics
2020-10-17 first PCB v01
2020-10-18 starting wiht 1chan
2020-10-18 edit readme
